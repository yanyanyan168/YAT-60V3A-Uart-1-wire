#include "ntc.h"

#define NTC_T_START_0P1C   (-400)  /* 表第0项对应温度：-40.0degC */
#define NTC_T_STEP_0P1C    (50)    /* 每格 5.0degC */


code u16 NCP18XH103_RT[34] =  { // 表格以 5degC 为一步，即-55, -54, - 53.....
/*-40 --  0degC */	19565u, 14817u, 11335u,	8756u,	6824u,	5365u,	4251u,	3389u,	2722u,
/* 5  --  50degC */	2202u,	 1793u,  1467u,	1208u,	1000u,	832u,	695u,	583u,	492u,	416u,
/*55  --  100degC*/	354u,	 301u,	  259u,	223u,	193u,	167u,	145u,	127u,	111u,	98u,
/*105 --  125degC*/	86u,	 76u,	  67u,	    60u,	53u };

/*
 * 函数：CH_R2T
 * 作用：NTC阻值 到 温度
 *
 * 输入：
 *   res10  -- NTC阻值（单位：10ohm）
 *             例如：
 *               1000 to 10000ohm
 *
 * 返回：
 *   温度（单位：0.1degC）
 *   例如：
 *     253  to 25.3degC
 *    -400 to -40.0degC
 *
 * ------------------------------------------------------------
 * 表说明：
 *
 * NCP18XH103_RT[]：
 *   1. 按“阻值从大到小”排列（NTC特性：温度越高阻值越小）
 *   2. 步进：5degC
 *   3. 第0项对应温度：-40degC
 *
 * 温度计算公式：
 *
 *   T(0.1degC) = -400 + index * 50
 *
 *   解释：
 *     -400  to -40.0degC
 *     每步50 to 5.0degC
 *
 * ------------------------------------------------------------
 * 算法流程：
 *
 *   1. 边界钳位（超量程处理）
 *   2. 顺序查表，找到 res 落在哪两个点之间
 *   3. 线性插值（带四舍五入）
 *
 * ------------------------------------------------------------
 * 插值公式（关键）：
 *
 *   在区间：
 *     r_hi >= res >= r_lo
 *
 *   温度增量：
 *
 *     delta_T =
 *       ( (r_hi - res) * STEP + (r_hi - r_lo)/2 ) / (r_hi - r_lo)
 *
 *   说明：
 *     STEP = 50（即5degC）
 *
 *     + (diff/2) 是整数四舍五入：
 *       A/B 到 (A + B/2) / B
 *
 * ------------------------------------------------------------
 */
s16 CH_R2T(u16 res10)
{
    u8  i;
    u8  last;
    u16 r_hi;
    u16 r_lo;
    u16 diff;
    s16 t_base;
    s16 t_last;

    /* 表最后一个索引 */
    last = (u8)(GET_ARRAY_LEN(NCP18XH103_RT) - 1u);

    /* 表最高温对应温度（末端温度） */
    t_last = (s16)(NTC_T_START_0P1C + (s16)last * NTC_T_STEP_0P1C);

    /*--------------------------------------------------
     * 1. 上边界钳位（低温端）
     * 阻值 >= 表最大值 到 温度低于量程 到 返回最小温度
     *--------------------------------------------------*/
    if (res10 >= NCP18XH103_RT[0])
    {
        return NTC_T_START_0P1C;   /* -40.0degC */
    }

    /*--------------------------------------------------
     * 2. 下边界钳位（高温端）
     * 阻值 <= 表最小值 到 温度高于量程 到 返回最大温度
     *--------------------------------------------------*/
    if (res10 <= NCP18XH103_RT[last])
    {
        return t_last;
    }

    /*--------------------------------------------------
     * 3. 查找区间
     *
     * 找到 i，使：
     *   table[i]   >= res >= table[i+1]
     *
     * 因为表是“递减排列”
     *--------------------------------------------------*/
    for (i = 0; i < last; i++)
    {
        if (res10 >= NCP18XH103_RT[i + 1u])
        {
            /* 区间两端阻值 */
            r_hi = NCP18XH103_RT[i];       /* 高阻（低温） */
            r_lo = NCP18XH103_RT[i + 1u];  /* 低阻（高温） */

            diff = (u16)(r_hi - r_lo);       /* 区间宽度 */

            /*--------------------------------------------------
             * 区间起点温度（单位：0.1degC）
             *--------------------------------------------------*/
            t_base = (s16)(NTC_T_START_0P1C +
                           (s16)i * NTC_T_STEP_0P1C);

            /*--------------------------------------------------
             * 线性插值（带四舍五入）
             *
             * 物理意义：
             *   res 越接近 r_lo 到 温度越接近下一格
             *
             * 计算：
             *
             *   delta_T =
             *     (r_hi - res) / (r_hi - r_lo) * STEP
             *
             * 整数实现（带四舍五入）：
             *
             *   ( (r_hi - res) * STEP + diff/2 ) / diff
             *
             *--------------------------------------------------*/
            return (s16)(t_base +
                   (s16)((((u16)(r_hi - res10) * (u16)NTC_T_STEP_0P1C)
                   + (diff >> 1)) / diff));
        }
    }

    /* 理论不会到这里（保险返回） */
    return t_last;
}

