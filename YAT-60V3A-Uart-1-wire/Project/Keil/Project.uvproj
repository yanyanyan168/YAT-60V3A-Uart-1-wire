# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: YAT-60V3A-UART-1-WIRE +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\App;..\..\Bsp
  asm include: ..\..\Libraries;..\..\Libraries\C51
  link misc: REMOVEUNUSED
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group App
    ../../App/: cal.c ch.c main.c pc_uart.c uart_1_wire.c
  group Bsp
    ../../Bsp/: adc.c bsp_init.c common.c fifo.c flash.c gpio.c isr.c ntc.c pwm.c stm32_crc.c timer.c uart.c
